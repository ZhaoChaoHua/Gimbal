# Keil uVision project XD_SPRain_BGC.uvprojx, settings and files
target xd_sprain_bgc (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: XD_SPRain_BGC +hex
  AfterMake: fromelf --bin !L --output xd_sprain_bgc.bin
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM
  c include: .\apps;.\driver;.\apps\Function;.\apps\Function\conversion;.\apps\Function\param;.\apps\Driver_Interface;.\apps\Thread;.\apps\SPRain_Math;.\apps\SPRain_Math\mathlib;.\apps\SPRain_Math\mathlib\math;.\apps\SPRain_Math\benchmarks;.\rt_thread\include;.\rt_thread\libcpu\arm\common;.\rt_thread\libcpu\arm\cortex-m4;.\rt_thread\components\drivers\include;.\rt_thread\components\finsh;.\rt_thread\components\dfs\include;.\rt_thread\components\dfs\filesystems\elmfat;.\Libraries\CMSIS\ST\STM32F4xx\Include;.\Libraries\CMSIS\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\apps\AHRS_Kalman;.\apps\Function\lib;.\apps\Function\param;..\BGC_V2_Last;.\rt_thread\include;.\apps;.\MainProcess;..\xd_bgc;.\apps\Code_from_generater;.\apps\Function\pinverse;.\apps\00-STM32_LIBRARIES;.\apps\00-HAL_DRIVERS\STM32F4xx_HAL_Driver\Inc;.\apps\00-HAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Include;.\apps\00-HAL_DRIVERS\CMSIS\Include;..\STM32Code
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Control
    ./apps/Function/: AttitudeControl.cpp PID.cpp P.cpp PD.cpp FuzzyLogic.cpp fuzzy_control.cpp excitation.cpp DirectionAlign.cpp
  group Attitude
    ./apps/Function/: Attitude.cpp attitude_filter.cpp filter.cpp accelerometer_calibration.cpp AccelCal.cpp AccelCalibrator.cpp SPR_matrix.cpp SPR_quat.cpp DCM_EKF_IMU.cpp NotchFilter.cpp AP_SmallEKF.cpp
    ./apps/Driver_Interface/: mpu6500.cpp bmm050.cpp bmm050_support.cpp bmm150.cpp
    ./apps/Function/conversion/: rotation.cpp
  group Comm
    ./apps/Function/: crc.cpp serial_com.cpp CAN_com.cpp mavlink_com.cpp
    ./apps/Driver_Interface/: fast_uart.c
    ./apps/: ringbuffer.cpp
  group Parameter_mg
    ./apps/Function/param/: parameter.cpp e2pfs.c e2pfs_port.c
    ./driver/: eeprom.c
  group Applications
    ./apps/: Gimbal.cpp startup.c application.cpp bgc_param.cpp
    ./apps/Driver_Interface/: time_measure.cpp timers.cpp
    ./apps/Function/: scheduler.cpp Upper_Control_Interface.cpp dataBox.cpp att2mot.cpp
  group Driver
    ./driver/: board.c bxcan.c can.c gpio.c idle_thread.c led.c position_sen.c spi_core.c spi_dev.c stm32_hw_spi.c stm32f4xx_it.c stm32f40x_timer.c usart.c
    ./apps/Driver_Interface/: hardward_bus.c stm32f4xx_sd.c
  group FileSystem
    ./rt_thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ./rt_thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group cortex_m4
    ./rt_thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ./rt_thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group STM32_StdPeriph
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Kernel
    ./rt_thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group DeviceDrivers
    ./rt_thread/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
    ./rt_thread/components/drivers/serial/: serial.c
    ./rt_thread/components/drivers/sdio/: block_dev.c mmc.c mmcsd_core.c sd.c sdio.c
  group finsh
    ./rt_thread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
  group Libraries
    ./apps/SPRain_Math/: AP_Math.cpp edc.cpp location.cpp matrix_alg.cpp matrix3.cpp polygon.cpp quaternion.cpp vector2.cpp vector3.cpp
    ./Libraries/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Mavlink
    E:/WorkSpace/OUT/: checksum.h mavlink_conversions.h mavlink_helpers.h mavlink_types.h protocol.h
    E:/WorkSpace/OUT/common/: common.h mavlink.h mavlink_msg_actuator_control_target.h mavlink_msg_adsb_vehicle.h mavlink_msg_altitude.h mavlink_msg_att_pos_mocap.h mavlink_msg_attitude.h mavlink_msg_attitude_quaternion.h mavlink_msg_attitude_quaternion_cov.h mavlink_msg_attitude_target.h mavlink_msg_auth_key.h mavlink_msg_autopilot_version.h mavlink_msg_battery_status.h mavlink_msg_camera_trigger.h mavlink_msg_change_operator_control.h mavlink_msg_change_operator_control_ack.h mavlink_msg_collision.h mavlink_msg_command_ack.h mavlink_msg_command_int.h mavlink_msg_command_long.h mavlink_msg_control_system_state.h mavlink_msg_data_stream.h mavlink_msg_data_transmission_handshake.h mavlink_msg_debug.h mavlink_msg_debug_vect.h mavlink_msg_distance_sensor.h mavlink_msg_encapsulated_data.h mavlink_msg_estimator_status.h mavlink_msg_extended_sys_state.h mavlink_msg_file_transfer_protocol.h mavlink_msg_follow_target.h mavlink_msg_global_position_int.h mavlink_msg_global_position_int_cov.h mavlink_msg_global_vision_position_estimate.h mavlink_msg_gps_global_origin.h mavlink_msg_gps_inject_data.h mavlink_msg_gps_input.h mavlink_msg_gps_raw_int.h mavlink_msg_gps_rtcm_data.h mavlink_msg_gps_rtk.h mavlink_msg_gps_status.h mavlink_msg_gps2_raw.h mavlink_msg_gps2_rtk.h mavlink_msg_heartbeat.h mavlink_msg_high_latency.h mavlink_msg_highres_imu.h mavlink_msg_hil_actuator_controls.h mavlink_msg_hil_controls.h mavlink_msg_hil_gps.h mavlink_msg_hil_optical_flow.h mavlink_msg_hil_rc_inputs_raw.h mavlink_msg_hil_sensor.h mavlink_msg_hil_state.h mavlink_msg_hil_state_quaternion.h mavlink_msg_home_position.h mavlink_msg_landing_target.h mavlink_msg_local_position_ned.h mavlink_msg_local_position_ned_cov.h mavlink_msg_local_position_ned_system_global_offset.h mavlink_msg_log_data.h mavlink_msg_log_entry.h mavlink_msg_log_erase.h mavlink_msg_log_request_data.h mavlink_msg_log_request_end.h mavlink_msg_log_request_list.h mavlink_msg_manual_control.h mavlink_msg_manual_setpoint.h mavlink_msg_memory_vect.h mavlink_msg_message_interval.h mavlink_msg_mission_ack.h mavlink_msg_mission_clear_all.h mavlink_msg_mission_count.h mavlink_msg_mission_current.h mavlink_msg_mission_item.h mavlink_msg_mission_item_int.h mavlink_msg_mission_item_reached.h mavlink_msg_mission_request.h mavlink_msg_mission_request_int.h mavlink_msg_mission_request_list.h mavlink_msg_mission_request_partial_list.h mavlink_msg_mission_set_current.h mavlink_msg_mission_write_partial_list.h mavlink_msg_named_value_float.h mavlink_msg_named_value_int.h mavlink_msg_nav_controller_output.h mavlink_msg_optical_flow.h mavlink_msg_optical_flow_rad.h mavlink_msg_param_map_rc.h mavlink_msg_param_request_list.h mavlink_msg_param_request_read.h mavlink_msg_param_set.h mavlink_msg_param_value.h mavlink_msg_ping.h mavlink_msg_position_target_global_int.h mavlink_msg_position_target_local_ned.h mavlink_msg_power_status.h mavlink_msg_radio_status.h mavlink_msg_raw_imu.h mavlink_msg_raw_pressure.h mavlink_msg_rc_channels.h mavlink_msg_rc_channels_override.h mavlink_msg_rc_channels_raw.h mavlink_msg_rc_channels_scaled.h mavlink_msg_request_data_stream.h mavlink_msg_resource_request.h mavlink_msg_safety_allowed_area.h mavlink_msg_safety_set_allowed_area.h mavlink_msg_scaled_imu.h mavlink_msg_scaled_imu2.h mavlink_msg_scaled_imu3.h mavlink_msg_scaled_pressure.h mavlink_msg_scaled_pressure2.h mavlink_msg_scaled_pressure3.h mavlink_msg_serial_control.h mavlink_msg_servo_output_raw.h mavlink_msg_set_actuator_control_target.h mavlink_msg_set_attitude_target.h mavlink_msg_set_gps_global_origin.h mavlink_msg_set_home_position.h mavlink_msg_set_mode.h mavlink_msg_set_position_target_global_int.h mavlink_msg_set_position_target_local_ned.h mavlink_msg_sim_state.h mavlink_msg_statustext.h mavlink_msg_sys_status.h mavlink_msg_system_time.h mavlink_msg_terrain_check.h mavlink_msg_terrain_data.h mavlink_msg_terrain_report.h mavlink_msg_terrain_request.h mavlink_msg_timesync.h mavlink_msg_v2_extension.h mavlink_msg_vfr_hud.h mavlink_msg_vibration.h mavlink_msg_vicon_position_estimate.h mavlink_msg_vision_position_estimate.h mavlink_msg_vision_speed_estimate.h mavlink_msg_wind_cov.h testsuite.h version.h
  group Filters
    ./: arm_fir_init_f32.c
    ./apps/: fir.cpp
    ./apps/Function/: arm_fir_f32.c fir_vec3f.cpp
